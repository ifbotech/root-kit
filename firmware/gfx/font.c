#include "font.h"
#include <stddef.h>

/* Cada glifo son siete filas de cinco columnas, concatenadas. El carácter
 * viaja junto a su dibujo para que sea imposible desalinear la tabla. */
typedef struct {
    char        ch;
    const char *rows;   /* 35 caracteres: '#' enciende, cualquier otro apaga */
} glyph_t;

static const glyph_t GLYPHS[] = {
{ ' ', "....." "....." "....." "....." "....." "....." "....." },
{ '!', "..#.." "..#.." "..#.." "..#.." "..#.." "....." "..#.." },
{'\'', "..#.." "..#.." "....." "....." "....." "....." "....." },
{ '(', "...#." "..#.." ".#..." ".#..." ".#..." "..#.." "...#." },
{ ')', ".#..." "..#.." "...#." "...#." "...#." "..#.." ".#..." },
{ '+', "....." "..#.." "..#.." "#####" "..#.." "..#.." "....." },
{ ',', "....." "....." "....." "....." ".##.." ".##.." ".#..." },
{ '-', "....." "....." "....." "#####" "....." "....." "....." },
{ '.', "....." "....." "....." "....." "....." ".##.." ".##.." },
{ '/', "....#" "...#." "...#." "..#.." ".#..." ".#..." "#...." },
{ '0', ".###." "#...#" "#..##" "#.#.#" "##..#" "#...#" ".###." },
{ '1', "..#.." ".##.." "..#.." "..#.." "..#.." "..#.." ".###." },
{ '2', ".###." "#...#" "....#" "...#." "..#.." ".#..." "#####" },
{ '3', "####." "....#" "....#" ".###." "....#" "....#" "####." },
{ '4', "...#." "..##." ".#.#." "#..#." "#####" "...#." "...#." },
{ '5', "#####" "#...." "####." "....#" "....#" "#...#" ".###." },
{ '6', "..##." ".#..." "#...." "####." "#...#" "#...#" ".###." },
{ '7', "#####" "....#" "...#." "..#.." ".#..." ".#..." ".#..." },
{ '8', ".###." "#...#" "#...#" ".###." "#...#" "#...#" ".###." },
{ '9', ".###." "#...#" "#...#" ".####" "....#" "...#." ".##.." },
{ ':', "....." ".##.." ".##.." "....." ".##.." ".##.." "....." },
{ '%', "##..#" "##.#." "...#." "..#.." ".#..." "#.##." "#.##." },
{ '<', "...#." "..#.." ".#..." "#...." ".#..." "..#.." "...#." },
{ '>', ".#..." "..#.." "...#." "....#" "...#." "..#.." ".#..." },
{ '?', ".###." "#...#" "....#" "...#." "..#.." "....." "..#.." },
{ '~', ".###." ".#.#." ".###." "....." "....." "....." "....." },  /* grado */
{ 'A', ".###." "#...#" "#...#" "#####" "#...#" "#...#" "#...#" },
{ 'B', "####." "#...#" "#...#" "####." "#...#" "#...#" "####." },
{ 'C', ".###." "#...#" "#...." "#...." "#...." "#...#" ".###." },
{ 'D', "###.." "#..#." "#...#" "#...#" "#...#" "#..#." "###.." },
{ 'E', "#####" "#...." "#...." "####." "#...." "#...." "#####" },
{ 'F', "#####" "#...." "#...." "####." "#...." "#...." "#...." },
{ 'G', ".###." "#...#" "#...." "#.###" "#...#" "#...#" ".###." },
{ 'H', "#...#" "#...#" "#...#" "#####" "#...#" "#...#" "#...#" },
{ 'I', ".###." "..#.." "..#.." "..#.." "..#.." "..#.." ".###." },
{ 'J', "..###" "...#." "...#." "...#." "...#." "#..#." ".##.." },
{ 'K', "#...#" "#..#." "#.#.." "##..." "#.#.." "#..#." "#...#" },
{ 'L', "#...." "#...." "#...." "#...." "#...." "#...." "#####" },
{ 'M', "#...#" "##.##" "#.#.#" "#.#.#" "#...#" "#...#" "#...#" },
{ 'N', "#...#" "##..#" "#.#.#" "#.#.#" "#..##" "#...#" "#...#" },
{ 'O', ".###." "#...#" "#...#" "#...#" "#...#" "#...#" ".###." },
{ 'P', "####." "#...#" "#...#" "####." "#...." "#...." "#...." },
{ 'Q', ".###." "#...#" "#...#" "#...#" "#.#.#" "#..#." ".##.#" },
{ 'R', "####." "#...#" "#...#" "####." "#.#.." "#..#." "#...#" },
{ 'S', ".####" "#...." "#...." ".###." "....#" "....#" "####." },
{ 'T', "#####" "..#.." "..#.." "..#.." "..#.." "..#.." "..#.." },
{ 'U', "#...#" "#...#" "#...#" "#...#" "#...#" "#...#" ".###." },
{ 'V', "#...#" "#...#" "#...#" "#...#" "#...#" ".#.#." "..#.." },
{ 'W', "#...#" "#...#" "#...#" "#.#.#" "#.#.#" "##.##" "#...#" },
{ 'X', "#...#" "#...#" ".#.#." "..#.." ".#.#." "#...#" "#...#" },
{ 'Y', "#...#" "#...#" ".#.#." "..#.." "..#.." "..#.." "..#.." },
{ 'Z', "#####" "....#" "...#." "..#.." ".#..." "#...." "#####" },
};

#define NGLYPHS ((int)(sizeof(GLYPHS) / sizeof(GLYPHS[0])))

static const char *find_glyph(char c)
{
    int i;
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    for (i = 0; i < NGLYPHS; i++) {
        if (GLYPHS[i].ch == c) {
            return GLYPHS[i].rows;
        }
    }
    return NULL;
}

bool rk_glyph_pixel(char ch, int col, int row)
{
    const char *g;

    if (col < 0 || col >= RK_GLYPH_W || row < 0 || row >= RK_GLYPH_H) {
        return false;
    }
    g = find_glyph(ch);
    return (g != NULL) && (g[row * RK_GLYPH_W + col] == '#');
}

int rk_text_w(const char *s, int scale)
{
    int n = 0;
    if (s == NULL || scale < 1) {
        return 0;
    }
    while (*s != '\0') {
        if (find_glyph(*s) != NULL) {
            n++;
        }
        s++;
    }
    if (n == 0) {
        return 0;
    }
    return (n * (RK_GLYPH_W + RK_TRACK) - RK_TRACK) * scale;
}

int rk_text(rk_fb_t *fb, int x, int y, const char *s, rk_color_t c, int scale)
{
    int x0 = x;
    int row, col;

    if (s == NULL || scale < 1) {
        return 0;
    }
    while (*s != '\0') {
        const char *g = find_glyph(*s);
        s++;
        if (g == NULL) {
            continue;
        }
        for (row = 0; row < RK_GLYPH_H; row++) {
            for (col = 0; col < RK_GLYPH_W; col++) {
                if (g[row * RK_GLYPH_W + col] == '#') {
                    if (scale == 1) {
                        rk_px(fb, x + col, y + row, c);
                    } else {
                        rk_fill_rect(fb, x + col * scale, y + row * scale,
                                     scale, scale, c);
                    }
                }
            }
        }
        x += (RK_GLYPH_W + RK_TRACK) * scale;
    }
    return x - x0 - (x > x0 ? RK_TRACK * scale : 0);
}

int rk_text_center(rk_fb_t *fb, int cx, int y, const char *s,
                   rk_color_t c, int scale)
{
    int w = rk_text_w(s, scale);
    return rk_text(fb, cx - w / 2, y, s, c, scale);
}

int rk_text_shadow(rk_fb_t *fb, int x, int y, const char *s,
                   rk_color_t c, rk_color_t shadow, int scale)
{
    rk_text(fb, x + scale, y + scale, s, shadow, scale);
    return rk_text(fb, x, y, s, c, scale);
}
